# Keil uVision project NIBP_Code.uvproj, settings and files
target Target 1 (MCS-51)
  device: SZC909 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0x0000-0xFFF5) CLOCK(32000000) MODC2 DPC MDU_R515
  output: NIBP_Code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Source Group 1
    ./Src/: NIBP_Main.c NIBP_Timer.c NIBP_Lcd.c NIBP_APP.c NIBP_ADC.c
    ./: OPTIONS_SZC909.A51
